# IAR project swis.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery; D:\parikshit\pdfs\micrium\Micrium\Software\uCOS-III\Source; D:\parikshit\pdfs\micrium\Micrium\Software\uC-CPU; D:\parikshit\pdfs\micrium\Micrium\Software\uC-CPU\ARM-Cortex-M4\IAR; D:\parikshit\micrium projects\main files; D:\parikshit\pdfs\micrium\Micrium\Examples\ST\STM32F4-DISCOVERY\BSP; D:\parikshit\pdfs\micrium\Micrium\Examples\ST\STM32F4-DISCOVERY\OS3-TCPIP-HTTPc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: swis.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ewarm
    ../../../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group micrium bsp
    ../../../pdfs/micrium/Micrium/Examples/ST/STM32F4-DISCOVERY/BSP/: bsp.c bsp_int.c bsp_periph.c
    ../../../pdfs/micrium/Micrium/Examples/ST/STM32F4-DISCOVERY/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group micrium files
    ../../../pdfs/micrium/Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group micrium header files
    ../../../pdfs/micrium/Micrium/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../pdfs/micrium/Micrium/Software/uC-Common/KAL/: kal.h
    ../../../pdfs/micrium/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group stm-discovery
    ../../../STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group stm-driver
    ../../../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
