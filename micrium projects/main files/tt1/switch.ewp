# IAR project switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\parikshit\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery; D:\parikshit\pdfs\micrium\Micrium\Software\uCOS-III\Source; D:\parikshit\pdfs\micrium\Micrium\Software\uC-CPU; D:\parikshit\pdfs\micrium\Micrium\Software\uC-CPU\ARM-Cortex-M4\IAR; D:\parikshit\micrium projects\main files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: switch.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: switch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group all header files
    ../../../pdfs/micrium/Micrium/Examples/ST/STM32F4-DISCOVERY/OS3-TCPIP-HTTPc/: app_cfg.h app_dns-c.h app_tcpip.h dhcp-c_cfg.h dns-c_cfg.h http-c_app.h http-c_cfg.h http-c_hooks.h includes.h lib_cfg.h net_cfg.h net_dev_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h trace_cfg.h trcConfig.h trcHardwarePort.h webpages.h
    ../: cpu_cfg.h lib_def.h
  group ewarm
    ../../../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group header
    ../../../pdfs/micrium/Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h
    ../../../pdfs/micrium/Micrium/Software/uC-CPU/: cpu_core.h cpu_def.h
    $EW_DIR$/arm/inc/c/: intrinsics.h
  group micrium
    ../../../pdfs/micrium/Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c
    ../../../pdfs/micrium/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../pdfs/micrium/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group stm-discovery
    ../../../STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group stm-driver
    ../../../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
