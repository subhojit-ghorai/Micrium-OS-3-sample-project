<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\p1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\main files\t1\t1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


